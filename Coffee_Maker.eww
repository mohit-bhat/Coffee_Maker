<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sparkfun_nrf52840_mini\blank\iar\Coffee_Maker_sparkfun_nrf52840_mini.ewp</path>
  </project>
  <batchBuild/>
</workspace>